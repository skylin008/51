# Keil uVision project blink_reg15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F104W STC
  cpu: IRAM(0-0x7F) IROM(0-0xFF8) CLOCK(35000000)
  output: blink_reg15 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: led.c
